# Keil uVision project TBook_Rev2b.uvprojx, settings and files
target TBv2b (6190000::V6.19::ARMCLANG)
  device: STM32F412VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TBookRev2b +hex
  BeforeMake: .\build_version_h.bat
  AfterMake: .\build_artifacts.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: TBOOKREV2B,STM32F412Vx, HSE_VALUE=8000000 _RTE_, FPM_DEFAULT
  c include: C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.9.0\CMSIS\RTOS2\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.9.0\CMSIS\RTOS2\RTX\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.9.0\CMSIS\Core\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.9.0\CMSIS\Driver\Include;C:\Keil_v5\ARM\PACK\ARM\mbedCrypto\3.0.1\include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.16.0\CMSIS\Driver;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.16.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.16.0\Drivers\STM32F4xx_HAL_Driver\Inc;.\Src\inc;.\Src\libmad\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x3f000
  memory RVCT10: RAM 0x2003f000 size 0x1000
  group TBook
    ./Src/: audio.cpp buffers.cpp codeci2c.cpp controlmanager.cpp csm.cpp dbgloop.cpp encaudio.cpp fileops.cpp fs_get_time.cpp gpio_stm32f4xx.cpp hardfault.s i2s_stm32f4xx.cpp inputmanager.cpp ledmanager.cpp linereader.cpp logger.cpp main.cpp mediaplayer.cpp mp3timing.cpp mp3tostream.cpp norlog.cpp packagedata.cpp powermanager.cpp preloadCSM.cpp tbook.cpp tbutil.cpp ti_aic3100.cpp USBD_User_Device_MSC_LUN.cpp w25q64jv.cpp wav.cpp
  group libMAD
    ./Src/libmad/: huffman.c layer3.c synth.c layer12.c frame.c decoder.c timer.c bit.c stream.c version.c fixed.c imdct_l_armasm.s
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Security:mbed Crypto 3.0.1, Compiler:Event Recorder 1.5.1, Compiler:I/O:File 1.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.15.3, File System:Drive:Memory Card 6.15.3, USB:CORE 6.16.1, USB:Device 6.16.1, USB:Device:MSC 6.16.1, CMSIS Driver:Flash:AT45DB641E 1.3.0, CMSIS Driver:Flash:AT45DB642D 1.3.0, CMSIS Driver:Flash:N25Q032A 1.1.0, CMSIS Driver:I2C 2.11, CMSIS Driver:MCI 2.10, CMSIS Driver:SPI 2.16, CMSIS Driver:USB Device:Full-speed 2.22, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:ADC 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:Flash 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:NAND 1.7.13, Device:STM32Cube HAL:NOR 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:QSPI 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:Startup 2.6.3
